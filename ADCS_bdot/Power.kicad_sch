File: ADCS_bdot/Power.kicad_sch (KiCad schematic)
At the start: 6 parts, among them U3 TPSM861253RDXR

Commit message: add: components
Other:
- moved on the sheet: C10, C8, R3, R8, R9, U3
